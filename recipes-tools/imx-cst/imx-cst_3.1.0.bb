require imx-cst.inc

SRC_URI += "file://0001-cst-Add-pkcs11-support.patch"
SRC_URI[md5sum] = "89a2d6c05253c4de9a1bf9d5710bb7ae"
SRC_URI[sha256sum] = "a8cb42c99e9bacb216a5b5e3b339df20d4c5612955e0c353e20f1bb7466cf222"
